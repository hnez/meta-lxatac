# Release commit created 2026-01-19 13:30:59 +0100
PV = "2026.01.0"
SRC_URI[sha256sum] = "219283d67c5d2f79bd22915b8a71906531223cb01e6e5b8d1658f299441e4169"

BAREBOX_TOOLS:append = " rk-usb-loader"
