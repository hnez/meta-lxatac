require rkdeveloptool.inc

SRCBRANCH = "master"
SRCREV = "46bb4c073624226c3f05b37b9ecc50bbcf543f5a"
