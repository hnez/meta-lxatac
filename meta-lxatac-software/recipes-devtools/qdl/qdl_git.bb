require qdl.inc

SRCBRANCH = "master"
SRCREV = "5db7794e9fdb73ed0c45384026cd8a62b5fff786"
PV = "2.1+${SRCREV}"
