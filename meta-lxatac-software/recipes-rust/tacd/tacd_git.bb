require tacd.inc

SRCBRANCH = "main"
SRCREV = "588a7e059aed85ce3928914cdedfbf05d5fadaa7"
PV = "0.1.0+git${SRCPV}"
