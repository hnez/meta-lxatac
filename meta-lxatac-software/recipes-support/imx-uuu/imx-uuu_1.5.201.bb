require imx-uuu.inc

SRCBRANCH = "master"
SRCREV = "727fc2b782156419a167ebfc8d9a4204ad2eedbf"
